# Keil uVision project GD32F303VCT6.uvprojx, settings and files
target APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot_app +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Firmware/robot_app.bin ./Objects/robot_app.axf
  AfterMake: C:\Program Files\Git\usr\bin\mv.exe .\Objects\robot_app.hex .\Firmware\
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__TARGET_FPU_VFP
  c include: ..\Robot-APP;.\CMSIS;.\CMSIS\GD32F30x\Include;.\GD32F30x_standard_peripheral\Include;.\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;.\FreeRTOS-Kernel;.\Hardware;.\vl6180x;.\CodeSamples\inc;.\Common_API;.\MsgHandler;.\Appliance;.\MPU6050;.\cm_backtrace;.\cm_backtrace\Languages\en-US;.\cm_backtrace\Languages\zh-CN;.\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./: main.c gd32f30x_it.c app_config.h
  group CMSIS
    ./CMSIS/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ./CMSIS/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group FreeRTOS
    ./FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ./FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
  group Hardware
    ./Hardware/: usart.c exti.c pwm.c iic.c flash_rw.c
  group VL6180xAPI
    ./vl6180x/: vl6180x_api.c vl6180x_i2c.c
  group VL6180xSamples
    ./CodeSamples/src/: vl6180x_simple_ranging.c vl6180x_range_interrupt.c
  group MPU6050
    ./MPU6050/: driver_mpu6050.c driver_mpu6050_basic.c driver_mpu6050_dmp.c driver_mpu6050_dmp_pedometer_test.c driver_mpu6050_dmp_read_test.c driver_mpu6050_dmp_tap_orient_motion_test.c driver_mpu6050_fifo.c driver_mpu6050_fifo_test.c driver_mpu6050_read_test.c driver_mpu6050_register_test.c gd32f303_driver_mpu6050_interface.c
  group MsgHandler
    ./MsgHandler/: ota.c fms.c handler.c control.c inquire.c online.c timing.c upload.c
  group utilize
    ./Common_API/: fifo.c print.c lib_mem_a.asm crc.c synchronous.c cJSON.c pid.c shell.c console.c time_counter.c
  group Appliance
    ./Appliance/: switch.c motor.c encoder.c IRremote.c
  group FaultTrace
    ./cm_backtrace/fault_handler/: cmb_fault.S
    ./cm_backtrace/: cm_backtrace.c
